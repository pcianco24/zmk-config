## config/boards/shields/my_keyboard/Kconfig.defconfig
```kconfig
if SHIELD_MY_KEYBOARD

config ZMK_KEYBOARD_NAME
    default "PieHandwired30"

endif
```
